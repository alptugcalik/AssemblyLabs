			AREA		main, READONLY, CODE
            THUMB

			EXTERN 		OutStr
			EXPORT		CONVRT

CONVRT		PROC
			PUSH {LR} 
			MOV R7,R5
			MOV R2,R4
			MOV R1,#10
			LDR R8,=0x04 ; TO WORK OUTSTR PROPERLY
			PUSH {R8}
			;FIND THE DIGITS OF THE NUMBER 
			;PUSH THEM INTO STACK
loop		UDIV R3,R2,R1
			MUL R3,R1
			SUB R6,R2,R3
			ADD R6,#48
			PUSH {R6}
			ADD  R7,#1
			CMP R3,#0
			BEQ exit
			UDIV R2,R3,R1
			B 	loop
exit		
			MOV R7,R5 ; COPY THE ADDRESS STORED IN R5
			ADDS R3,#1; ZERO FLAG IS REFRESHED
			;POP EACH DIGIT ONE BY ONE 
loop2		POP {R6}
			STRB R6,[R7] ; STORE THEM IN THE LOCATION POINTED BY R5
			CMP R6,R8
			BEQ  exit2
			ADD  R7,#1 ;INCREMENT THE ADDRESS BY 1 BYTE
			B   loop2
exit2
			;PRINT OUT EACH DIGIT BY OUTSTR
			BL   OutStr
			POP {LR}
			BX  LR
			ENDP
			ALIGN
			END
			